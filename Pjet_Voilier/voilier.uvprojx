# Keil uVision project voilier.uvprojx, settings and files
target simul (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpio
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: \\netapp2\agbeti-m\KeilMarcoBenjamin\ProjetVoilier\Drivers\Include;..\Services\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group MesSources
    ./Source/: Principal.c
  group MesDrivers
    ../Drivers/Include/: MyTimer.h MyUART.h Driver_GPIO.h
    ../Drivers/Source/: Driver_GPIO.c MyTimer.c MyUART.c
  group MesServices
    ../Services/Include/: Transmission.h BordageAutomatique.h
    ../Services/Source/: Transmission.c BordageAutomatique.c
target real (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: gpio
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
